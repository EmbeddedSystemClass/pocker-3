# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\STM32F4xx_StdPeriph_Driver\src; D:\REPOSITORY\GIT\POKER\POCKER STD_LIB\librarys
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: librarys\stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    librarys/: attributes.h
    inc/: defines.h tm_stm32f4_mfrc522.c tm_stm32f4_mfrc522.h tm_stm32f4_spi.c tm_stm32f4_spi.h
    ./: main.c
    librarys/STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
    librarys/STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    librarys/STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_spi.c
    librarys/STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h stm32f4xx_spi.h
    librarys/STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
